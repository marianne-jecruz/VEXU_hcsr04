# Keil uVision project VEXU_hcsr04.uvprojx, settings and files
target hcsr04 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VEXU_hcsr04 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main_hcsr04.c hcsr04.c hcsr04.h
  group inc
    ./inc/: startup.s PLL.c Unified_Port_Init.c Timer0A.c Timer0A.h Timer2A.c Timer5A.c Timer5A.h Timer1A.c Timer1A.h UART.c UART.h
